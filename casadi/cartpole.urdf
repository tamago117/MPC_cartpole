Commit message: in the middle cuda program

File: casadi/cartpole.urdf (robot description, URDF)
Before this commit: robot physics, 4 links, 3 joints
Joints:
- joint slider_to_cart: limit lower=-15 upper=15 effort=1000.0 velocity=5 -> lower=-15 upper=15 effort=1000.0 velocity=0
